# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Lesson_5\cmsis;..\..\..\Lesson_5\cmsis_boot\startup;..\..\..\Lesson_5\cmsis_boot;..\..\..\Lesson_5\cmsis_lib\include;..\..\..\Lesson_5\cmsis_lib\source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../../Lesson_5/cmsis/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../Lesson_5/cmsis_boot/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
    ../../../Lesson_5/cmsis_lib/include/: lcd.h stm32f4xx_gpio.h stm32f4xx_rcc.h
    ../../../Lesson_5/cmsis_lib/source/: stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../../../Lesson_5/Lesson_5/Debug/obj/: main.o startup_stm32f4xx.o stm32f4xx_gpio.o stm32f4xx_rcc.o system_stm32f4xx.o
    ../../../Lesson_5/: main.c
